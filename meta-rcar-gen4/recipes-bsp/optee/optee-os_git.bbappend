DESCRIPTION = "OP-TEE OS"

COMPATIBLE_MACHINE = "vc4"

