DESCRIPTION = "OP-TEE Client"

COMPATIBLE_MACHINE = "vc4"

