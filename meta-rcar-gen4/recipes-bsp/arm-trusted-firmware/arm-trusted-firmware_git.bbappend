DESCRIPTION = "ARM Trusted Firmware"

COMPATIBLE_MACHINE = "vc4"
