require vc-image-base.inc

DESCRIPTION = "Renesas VehicleComputer Base image"

IMAGE_FEATURES += "empty-root-password allow-empty-password"
