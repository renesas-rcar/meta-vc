RENESAS_BSP_URL = "git://github.com/renesas-rcar/linux-bsp.git"
BRANCH = "v4.14.75-ltsi/rcar-3.9.7"
SRCREV = "59ccbcefaebb4a33110e11fb87f3811cd59f192d"

SRC_URI = "${RENESAS_BSP_URL};branch=${BRANCH}"
