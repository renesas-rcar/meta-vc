MMNGR_CFG_h3vc = "MMNGR_SALVATORX"

